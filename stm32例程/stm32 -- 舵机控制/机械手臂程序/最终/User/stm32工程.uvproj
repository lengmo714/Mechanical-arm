# Keil uVision project stm32工程.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32工程 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\Libraries\inc;..\User;..\MY_wen_jian\delay;..\MY_wen_jian\sys;..\MY_wen_jian\usart;..\MY_wen_jian\MY_time_Conf;..\MY_wen_jian\TIMER;..\MY_wen_jian\EXTI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MY_wen_jian
    ../MY_wen_jian/delay/: delay.c
    ../MY_wen_jian/usart/: usart.c
    ../MY_wen_jian/MY_time_Conf/: MY_time_Conf.c
    ../MY_wen_jian/sys/: sys.c
    ../MY_wen_jian/TIMER/: timer.c
    ../MY_wen_jian/EXTI/: exti.c
